# Keil uVision project stc15quad_prj.uvproj, settings and files
target 目标 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: stc15_quad +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: main.c STC15W4K-PWM.C LT8910.c IMU.C MPU-6050.c KalmanFilter.c globeVar.c
